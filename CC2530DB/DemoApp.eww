<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DemoApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>DemoApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>DemoApp</project>
        <configuration>SensorEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


